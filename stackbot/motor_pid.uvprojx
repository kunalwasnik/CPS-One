# Keil uVision project motor_pid.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00800000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: motor_pid
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x800000 size 0x20000
  group Source Group 1
    ./: adc.c audio.c gpio.c i2c.c ledbtn.c lsm303agr.c motor.c printf.c pwm.c timer.c uart.c main.c adc.h audio.h bsp.h gpio.h hardware.h i2c.h ledbtn.h lsm303agr.h microbit.h motor.h myled.h nrf52833.h printf.h pwm.h timer.h uart.h touch.c touch.h button.h radio.c radio.h
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
